# Keil uVision project main.uvprojx, settings and files
target chassis (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gpio_toggle_output_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: D:\TI\CCS\mspm0_sdk_2_10_00_04\tools\keil\syscfg.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../;D:\TI\CCS\mspm0_sdk_2_10_00_04\source;D:\TI\CCS\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include;..\DVE;..\BSP;..\app
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: D:/TI/CCS/mspm0_sdk_2_10_00_04/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ./: startup_mspm0g350x_uvision.s
    ../: ti_msp_dl_config.h ti_msp_dl_config.c delay.c delay.h interrupt.c interrupt.h main.c main.syscfg PID.c PID.h total.h
  group app
    ../app/: app_command.c app_command.h app_trace.c app_trace.h
  group BSP
    ../BSP/: bsp_bluetooth.c bsp_bluetooth.h bsp_encoder.c bsp_encoder_interrupt.c bsp_encoder.h bsp_uart.c bsp_uart.h bsp_chassis_motor.c bsp_chassis_motor.h
  group DVE
    ../DVE/: dve_chassis.c dve_chassis.h dve_chassis_interrupt.c dve_ir_sensor.c dve_ir_sensor.h
